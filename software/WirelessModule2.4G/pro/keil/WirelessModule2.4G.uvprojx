# Keil uVision project WirelessModule2.4G.uvprojx, settings and files
target WirelessModule2.4G (ARM-ADS)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.1.5.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: WirelessModule2_4G +hex
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F0XX_MD
  c include: ..\..\hal;..\..\lib\STM32F0xx_StdPeriph_Driver\inc;..\..\app;..\..\app\net;..\..\app\net\NRF24L01P
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group app
    ../../app/: main.c Sys.c SysTimer.c WirelessModule.c DevicesManager.c MProto.c PowerManager.c Manufacture.c testWM.c
  group hal
    ../../hal/: HalClk.c HalCommon.c HalFlash.c HalGPIO.c HalSpi.c HalTimer.c HalUart.c HalWait.c HalPower.c
  group net
    ../../app/net/: NetLayer.c PHYLayer.c
    ../../app/net/NRF24L01P/: NRF24L01.c
  group lib
    ../../lib/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_dma.c stm32f0xx_exti.c stm32f0xx_flash.c stm32f0xx_gpio.c stm32f0xx_iwdg.c stm32f0xx_misc.c stm32f0xx_pwr.c stm32f0xx_rcc.c stm32f0xx_spi.c stm32f0xx_syscfg.c stm32f0xx_tim.c stm32f0xx_usart.c
software components: CMSIS:CORE 5.0.0, Device:Startup 1.5.0
